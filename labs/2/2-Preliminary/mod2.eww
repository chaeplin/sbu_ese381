<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\1\hardware_delay_test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\2\hardware_pulse_test.ewp</path>
  </project>
  <batchBuild/>
</workspace>


